# Keil uVision project I2C.uvprojx, settings and files
target I2C (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I2C
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123GH6PM
  c misc: --c99
  c include: C:\TivaWare_C_Series-2.2.0.295\driverlib;C:\TivaWare_C_Series-2.2.0.295\inc;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s I2CTestMain.c ssd1306.c ssd1306.h font.c i2c.h comp.c cpu.c sw_crc.c
    ../TivaWare_C_Series-2.2.0.295/driverlib/: gpio.c i2c.c interrupt.c sysctl.c
software components: CMSIS:CORE 5.0.2
